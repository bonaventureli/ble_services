# Keil uVision project ikcmd.uvprojx, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: ikcmd +hex (library)
  AfterMake: cmd.exe /C copy .\_build\ikcmd.lib ..\..\..\ikif\lib\ikcmd.lib
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: FLOAT_ABI_HARD FREERTOS NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=1024 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\nRF5_SDK_15.2.0\components;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_advertising;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_dtm;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_racp;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_ancs_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_ans_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_bas;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_bas_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_cscs;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_cts_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_dfu;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_dis;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_gls;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_hids;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_hrs;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_hrs_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_hts;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_ias;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_ias_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_lbs;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_lbs_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_lls;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_nus;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_nus_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_rscs;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_rscs_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_tps;..\..\..\nRF5_SDK_15.2.0\components\ble\common;..\..\..\nRF5_SDK_15.2.0\components\ble\nrf_ble_gatt;..\..\..\nRF5_SDK_15.2.0\components\ble\nrf_ble_qwr;..\..\..\nRF5_SDK_15.2.0\components\ble\peer_manager;..\..\..\nRF5_SDK_15.2.0\components\drivers_nrf\usbd;..\..\..\nRF5_SDK_15.2.0\components\libraries\atomic;..\..\..\nRF5_SDK_15.2.0\components\libraries\atomic_fifo;..\..\..\nRF5_SDK_15.2.0\components\libraries\atomic_flags;..\..\..\nRF5_SDK_15.2.0\components\libraries\balloc;..\..\..\nRF5_SDK_15.2.0\components\libraries\bootloader\ble_dfu;..\..\..\nRF5_SDK_15.2.0\components\libraries\cli;..\..\..\nRF5_SDK_15.2.0\components\libraries\crc16;..\..\..\nRF5_SDK_15.2.0\components\libraries\crc32;..\..\..\nRF5_SDK_15.2.0\components\libraries\crypto;..\..\..\nRF5_SDK_15.2.0\components\libraries\csense;..\..\..\nRF5_SDK_15.2.0\components\libraries\csense_drv;..\..\..\nRF5_SDK_15.2.0\components\libraries\delay;..\..\..\nRF5_SDK_15.2.0\components\libraries\ecc;..\..\..\nRF5_SDK_15.2.0\components\libraries\experimental_section_vars;..\..\..\nRF5_SDK_15.2.0\components\libraries\experimental_task_manager;..\..\..\nRF5_SDK_15.2.0\components\libraries\fds;..\..\..\nRF5_SDK_15.2.0\components\libraries\fstorage;..\..\..\nRF5_SDK_15.2.0\components\libraries\gfx;..\..\..\nRF5_SDK_15.2.0\components\libraries\gpiote;..\..\..\nRF5_SDK_15.2.0\components\libraries\hardfault;..\..\..\nRF5_SDK_15.2.0\components\libraries\hardfault\nrf52;..\..\..\nRF5_SDK_15.2.0\components\libraries\hci;..\..\..\nRF5_SDK_15.2.0\components\libraries\led_softblink;..\..\..\nRF5_SDK_15.2.0\components\libraries\log;..\..\..\nRF5_SDK_15.2.0\components\libraries\log\src;..\..\..\nRF5_SDK_15.2.0\components\libraries\low_power_pwm;..\..\..\nRF5_SDK_15.2.0\components\libraries\mem_manager;..\..\..\nRF5_SDK_15.2.0\components\libraries\memobj;..\..\..\nRF5_SDK_15.2.0\components\libraries\mpu;..\..\..\nRF5_SDK_15.2.0\components\libraries\mutex;..\..\..\nRF5_SDK_15.2.0\components\libraries\pwm;..\..\..\nRF5_SDK_15.2.0\components\libraries\pwr_mgmt;..\..\..\nRF5_SDK_15.2.0\components\libraries\queue;..\..\..\nRF5_SDK_15.2.0\components\libraries\ringbuf;..\..\..\nRF5_SDK_15.2.0\components\libraries\scheduler;..\..\..\nRF5_SDK_15.2.0\components\libraries\sdcard;..\..\..\nRF5_SDK_15.2.0\components\libraries\sensorsim;..\..\..\nRF5_SDK_15.2.0\components\libraries\slip;..\..\..\nRF5_SDK_15.2.0\components\libraries\sortlist;..\..\..\nRF5_SDK_15.2.0\components\libraries\spi_mngr;..\..\..\nRF5_SDK_15.2.0\components\libraries\stack_guard;..\..\..\nRF5_SDK_15.2.0\components\libraries\strerror;..\..\..\nRF5_SDK_15.2.0\components\libraries\svc;..\..\..\nRF5_SDK_15.2.0\components\libraries\timer;..\..\..\nRF5_SDK_15.2.0\components\libraries\usbd\class\hid\mouse;..\..\..\nRF5_SDK_15.2.0\components\libraries\usbd\class\msc;..\..\..\nRF5_SDK_15.2.0\components\libraries\util;..\..\..\nRF5_SDK_15.2.0\components\softdevice\common;..\..\..\nRF5_SDK_15.2.0\components\softdevice\s132\headers;..\..\..\nRF5_SDK_15.2.0\components\softdevice\s132\headers\nrf52;..\..\..\nRF5_SDK_15.2.0\external\fprintf;..\..\..\nRF5_SDK_15.2.0\external\freertos\config;..\..\..\nRF5_SDK_15.2.0\external\freertos\portable\ARM\nrf52;..\..\..\nRF5_SDK_15.2.0\external\freertos\portable\CMSIS\nrf52;..\..\..\nRF5_SDK_15.2.0\external\freertos\source\include;..\..\..\nRF5_SDK_15.2.0\external\segger_rtt;..\..\..\nRF5_SDK_15.2.0\integration\nrfx;..\..\..\nRF5_SDK_15.2.0\integration\nrfx\legacy;..\..\..\nRF5_SDK_15.2.0\modules\nrfx;..\..\..\nRF5_SDK_15.2.0\modules\nrfx\drivers\include;..\..\..\nRF5_SDK_15.2.0\modules\nrfx\hal;..\..\..\nRF5_SDK_15.2.0\modules\nrfx\mdk;..\..\inc;..\..\..\ikcmd\inc;..\..\..\ikssl\inc;..\..\..\ikif\inc
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DFREERTOS,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=1024,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\..\..\nRF5_SDK_15.2.0\components;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_advertising;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_dtm;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_racp;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_ancs_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_ans_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_bas;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_bas_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_cscs;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_cts_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_dfu;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_dis;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_gls;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_hids;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_hrs;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_hrs_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_hts;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_ias;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_ias_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_lbs;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_lbs_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_lls;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_nus;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_nus_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_rscs;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_rscs_c;..\..\..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_tps;..\..\..\nRF5_SDK_15.2.0\components\ble\common;..\..\..\nRF5_SDK_15.2.0\components\ble\nrf_ble_gatt;..\..\..\nRF5_SDK_15.2.0\components\ble\nrf_ble_qwr;..\..\..\nRF5_SDK_15.2.0\components\ble\peer_manager;..\..\..\nRF5_SDK_15.2.0\components\boards;..\..\..\nRF5_SDK_15.2.0\components\drivers_nrf\usbd;..\..\..\nRF5_SDK_15.2.0\components\libraries\atomic;..\..\..\nRF5_SDK_15.2.0\components\libraries\atomic_fifo;..\..\..\nRF5_SDK_15.2.0\components\libraries\atomic_flags;..\..\..\nRF5_SDK_15.2.0\components\libraries\balloc;..\..\..\nRF5_SDK_15.2.0\components\libraries\bootloader\ble_dfu;..\..\..\nRF5_SDK_15.2.0\components\libraries\bsp;..\..\..\nRF5_SDK_15.2.0\components\libraries\button;..\..\..\nRF5_SDK_15.2.0\components\libraries\cli;..\..\..\nRF5_SDK_15.2.0\components\libraries\crc16;..\..\..\nRF5_SDK_15.2.0\components\libraries\crc32;..\..\..\nRF5_SDK_15.2.0\components\libraries\crypto;..\..\..\nRF5_SDK_15.2.0\components\libraries\csense;..\..\..\nRF5_SDK_15.2.0\components\libraries\csense_drv;..\..\..\nRF5_SDK_15.2.0\components\libraries\delay;..\..\..\nRF5_SDK_15.2.0\components\libraries\ecc;..\..\..\nRF5_SDK_15.2.0\components\libraries\experimental_section_vars;..\..\..\nRF5_SDK_15.2.0\components\libraries\experimental_task_manager;..\..\..\nRF5_SDK_15.2.0\components\libraries\fds;..\..\..\nRF5_SDK_15.2.0\components\libraries\fstorage;..\..\..\nRF5_SDK_15.2.0\components\libraries\gfx;..\..\..\nRF5_SDK_15.2.0\components\libraries\gpiote;..\..\..\nRF5_SDK_15.2.0\components\libraries\hardfault;..\..\..\nRF5_SDK_15.2.0\components\libraries\hardfault\nrf52;..\..\..\nRF5_SDK_15.2.0\components\libraries\hci;..\..\..\nRF5_SDK_15.2.0\components\libraries\led_softblink;..\..\..\nRF5_SDK_15.2.0\components\libraries\log;..\..\..\nRF5_SDK_15.2.0\components\libraries\log\src;..\..\..\nRF5_SDK_15.2.0\components\libraries\low_power_pwm;..\..\..\nRF5_SDK_15.2.0\components\libraries\mem_manager;..\..\..\nRF5_SDK_15.2.0\components\libraries\memobj;..\..\..\nRF5_SDK_15.2.0\components\libraries\mpu;..\..\..\nRF5_SDK_15.2.0\components\libraries\mutex;..\..\..\nRF5_SDK_15.2.0\components\libraries\pwm;..\..\..\nRF5_SDK_15.2.0\components\libraries\pwr_mgmt;..\..\..\nRF5_SDK_15.2.0\components\libraries\queue;..\..\..\nRF5_SDK_15.2.0\components\libraries\ringbuf;..\..\..\nRF5_SDK_15.2.0\components\libraries\scheduler;..\..\..\nRF5_SDK_15.2.0\components\libraries\sdcard;..\..\..\nRF5_SDK_15.2.0\components\libraries\sensorsim;..\..\..\nRF5_SDK_15.2.0\components\libraries\slip;..\..\..\nRF5_SDK_15.2.0\components\libraries\sortlist;..\..\..\nRF5_SDK_15.2.0\components\libraries\spi_mngr;..\..\..\nRF5_SDK_15.2.0\components\libraries\stack_guard;..\..\..\nRF5_SDK_15.2.0\components\libraries\strerror;..\..\..\nRF5_SDK_15.2.0\components\libraries\svc;..\..\..\nRF5_SDK_15.2.0\components\libraries\timer;..\..\..\nRF5_SDK_15.2.0\components\libraries\twi_mngr;..\..\..\nRF5_SDK_15.2.0\components\libraries\twi_sensor;..\..\..\nRF5_SDK_15.2.0\components\libraries\usbd;..\..\..\nRF5_SDK_15.2.0\components\libraries\usbd\class\audio;..\..\..\nRF5_SDK_15.2.0\components\libraries\usbd\class\cdc;..\..\..\nRF5_SDK_15.2.0\components\libraries\usbd\class\cdc\acm;..\..\..\nRF5_SDK_15.2.0\components\libraries\usbd\class\hid;..\..\..\nRF5_SDK_15.2.0\components\libraries\usbd\class\hid\generic;..\..\..\nRF5_SDK_15.2.0\components\libraries\usbd\class\hid\kbd;..\..\..\nRF5_SDK_15.2.0\components\libraries\usbd\class\hid\mouse;..\..\..\nRF5_SDK_15.2.0\components\libraries\usbd\class\msc;..\..\..\nRF5_SDK_15.2.0\components\libraries\util;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\conn_hand_parser;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\ac_rec;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\common;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\hs_rec;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\generic\message;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\generic\record;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\launchapp;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\parser\message;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\parser\record;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\text;..\..\..\nRF5_SDK_15.2.0\components\nfc\ndef\uri;..\..\..\nRF5_SDK_15.2.0\components\nfc\t2t_lib;..\..\..\nRF5_SDK_15.2.0\components\nfc\t2t_lib\hal_t2t;..\..\..\nRF5_SDK_15.2.0\components\nfc\t2t_parser;..\..\..\nRF5_SDK_15.2.0\components\nfc\t4t_lib;..\..\..\nRF5_SDK_15.2.0\components\nfc\t4t_lib\hal_t4t;..\..\..\nRF5_SDK_15.2.0\components\nfc\t4t_parser\apdu;..\..\..\nRF5_SDK_15.2.0\components\nfc\t4t_parser\cc_file;..\..\..\nRF5_SDK_15.2.0\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\nRF5_SDK_15.2.0\components\nfc\t4t_parser\tlv;..\..\..\nRF5_SDK_15.2.0\components\softdevice\common;..\..\..\nRF5_SDK_15.2.0\components\softdevice\s132\headers;..\..\..\nRF5_SDK_15.2.0\components\softdevice\s132\headers\nrf52;..\..\..\nRF5_SDK_15.2.0\external\fprintf;..\..\..\nRF5_SDK_15.2.0\external\freertos\config;..\..\..\nRF5_SDK_15.2.0\external\freertos\portable\ARM\nrf52;..\..\..\nRF5_SDK_15.2.0\external\freertos\portable\CMSIS\nrf52;..\..\..\nRF5_SDK_15.2.0\external\freertos\source\include;..\..\..\nRF5_SDK_15.2.0\external\segger_rtt;..\..\..\nRF5_SDK_15.2.0\external\utf_converter;..\..\..\nRF5_SDK_15.2.0\integration\nrfx;..\..\..\nRF5_SDK_15.2.0\integration\nrfx\legacy;..\..\..\nRF5_SDK_15.2.0\modules\nrfx;..\..\..\nRF5_SDK_15.2.0\modules\nrfx\drivers\include;..\..\..\nRF5_SDK_15.2.0\modules\nrfx\hal;..\..\..\nRF5_SDK_15.2.0\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x200057b8 size 0xa848
  link misc: --diag_suppress 6330
  group source
    ../../src/: ikcmdhandle.c ikcmdif.c
software components: CMSIS:CORE 4.3.0
